options:
  parameters:
    author: u
    generate_options: qt_gui
    id: default
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 25e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    type: complex
    ymax: '-60'
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    balance0: '0'
    center_freq0: freq
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'False'
    dev: driver=fobos
    devname: custom
    gain_mode0: Specific
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
